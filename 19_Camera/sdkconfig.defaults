## 1_12_camera/main/Kconfig.projbuild
```kconfig
menu "Example Configuration"
    
    config  CAMERA_JPEG_MODE
        bool "jpeg mode"
        
endmenu
```
